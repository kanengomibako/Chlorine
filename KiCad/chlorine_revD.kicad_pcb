# Repository kanengomibako/Chlorine

File README.md:

# Chlorine
### STM32 Programmable Digital Effects Pedal
STM32マイコンを搭載した、プログラミング可能なデジタルエフェクターです。C言語またはC++で開発を行います。もちろんプログラム書き込み後は単体のエフェクターとして動作可能です。

旧機種 [Sodium](https://github.com/kanengomibako/Sodium) と比較すると、処理能力は2倍以上です。また、最大入出力音量増加・ノイズ低減・操作系強化・USBアップデート機能追加等、大幅にアップグレードされました。

### 別途必要なもの
- DC9V（センターマイナス）出力のACアダプターで、0.5A以上の電流出力が可能なもの
> [!caution]
> 10V以上の電圧で連続使用しないでください。故障の原因となります。

- PC（Windows、macOS、Linux いずれも可、64bit推奨）<br/>※ 32bit環境では使用できる開発ソフトが限られます。
- STM32対応のデバッガ（プログラム書き込みやデバッグを行う機器）<br/>
	→ [デバッガ購入について](https://github.com/kanengomibako/Sodium/blob/main/Docs/005_%E3%83%87%E3%83%90%E3%83%83%E3%82%AC%E8%B3%BC%E5%85%A5%E3%81%AB%E3%81%A4%E3%81%84%E3%81%A6.md)
- PCとデバッガを接続するUSBケーブル
- デバッガとChlorine本体を接続するケーブル<br/>
	→ [コネクタ付コード 3P](https://akizukidenshi.com/catalog/g/gC-15384/) と [両端ロングピンヘッダー](https://akizukidenshi.com/catalog/g/g109055/) 等

### 各部の機能
- INPUT 端子：ギターや他の機器からの出力を接続します（ステレオ入力可）。
- OUTPUT 端子：アンプや他の機器の入力へ接続します（ステレオ出力可）。
- +9VDC 端子：ACアダプターを接続します。
- 各スイッチ・ロータリーエンコーダ：任意の機能をプログラミング可能です。サンプルプログラムの操作については[別ページ](Docs/000_初期プログラムについて.md)をご参照ください。
- MIDI 入力端子：他の機器からのMIDI信号を入力することができます（TRS MIDI）。
- Serial Wire Debug (SWD) 接続ピンソケット：デバッガのSWCLK、GND、SWDIOピンを、Chlorineのピンソケットへそれぞれ接続します。
- USB Type-C 入力端子：USB Type-Cケーブルを接続することができます。

### 資料
- [初期プログラムについて](Docs/000_初期プログラムについて.md)
- [デバッガ購入について](https://github.com/kanengomibako/Sodium/blob/main/Docs/005_%E3%83%87%E3%83%90%E3%83%83%E3%82%AC%E8%B3%BC%E5%85%A5%E3%81%AB%E3%81%A4%E3%81%84%E3%81%A6.md)
- [プログラム書き込み・デバッグ](Docs/001_プログラム書き込み・デバッグ.md)
- [マイコンの機能設定](Docs/003_マイコンの機能設定.md)
- [プログラミング概要](Docs/004_プログラミング概要.md)
- [Chlorine プログラム書込ツール](https://kanengomibako.github.io/pages/00361_Chlorine_WebUSBDFU.html)
- [開発記録](https://kanengomibako.github.io/pages/00364_chlorine.html)

エフェクトについては、旧機種Sodium用のページをご参照ください。基本的にはChlorineも同じプログラム内容です。

- [エフェクト種類管理（fx.cpp）について](https://github.com/kanengomibako/Sodium/blob/main/Docs/100_%E3%82%A8%E3%83%95%E3%82%A7%E3%82%AF%E3%83%88%E7%A8%AE%E9%A1%9E%E7%AE%A1%E7%90%86%EF%BC%88fx.cpp%EF%BC%89%E3%81%AB%E3%81%A4%E3%81%84%E3%81%A6.md)

- [エフェクトファイル（fx_○○.hpp）について](https://github.com/kanengomibako/Sodium/blob/main/Docs/110_%E3%82%A8%E3%83%95%E3%82%A7%E3%82%AF%E3%83%88%E3%83%95%E3%82%A1%E3%82%A4%E3%83%AB%EF%BC%88fx_%E2%97%8B%E2%97%8B.hpp%EF%BC%89%E3%81%AB%E3%81%A4%E3%81%84%E3%81%A6.md)

- [各エフェクト説明目次](https://github.com/kanengomibako/Sodium/blob/main/Docs/200_%E5%90%84%E3%82%A8%E3%83%95%E3%82%A7%E3%82%AF%E3%83%88%E8%AA%AC%E6%98%8E%E7%9B%AE%E6%AC%A1.md)

| 主な仕様 |  |
| - | - |
| サンプリング周波数 | 48 kHz（44.1 kHz または 96 kHz に設定可能） |
| 内部演算 | 32 ビット浮動小数点 |
| AD、DA変換 | 24 ビット |
| レイテンシ | 1.2 ミリ秒（サンプルプログラム実行時） |
| 最大入力レベル | 2.0 Vrms (+8.2 dBu) |
| 入力インピーダンス | 1 MΩ |
| 最大出力レベル | 2.0 Vrms (+8.2 dBu) |
| 出力インピーダンス | 1 kΩ |
| バイパス | バッファード・バイパス（バイパス音もAD/DA変換されます） |
| コントロール | 押しボタンスイッチ付きロータリーエンコーダ × 4<br/>押しボタンスイッチ × 4　フットスイッチ × 2 |
| ディスプレイ | 1.77インチ 液晶ディスプレイ　カラー 160 × 128 ドット |
| インジケーター | 3色LED（直径5mm） |
| 接続端子 | INPUT端子　OUTPUT端子　電源入力端子　MIDI入力端子<br/>Serial Wire Debug (SWD) 接続ピンソケット　USB Type-C 入力端子 |
| 消費電流 | 180 mA |
| 外形寸法 | 幅 76 mm × 奥行 100 mm × 高さ 45 mm |
| 質量 | 200 g |

## KiCad design KiCad/chlorine_revD.kicad_pcb

Parts:
C1, C2, C3, C4, C15, C16: 47u; C_1206_3216Metric; MPN C96123
C5, C8, C9, C10, C11, C12, C13, C14, C37, C39, C52, C101: 100n; C_0603_1608Metric; MPN C14663
C6, C7: 22u; C_1206_3216Metric; MPN C12891
C17, C18: 1u; C_1210_3225Metric; MPN C569895
C19, C20, C23, C24, C25, C26, C31, C32, C38, C50, C51: 10u; CP_EIA-3216-10_Kemet-I; MPN C7171
C21, C22, C27, C28, C55, C56: 2.2n; C_0805_2012Metric; MPN C28260
C29, C30, C53, C54, C57, C58: 470p; C_0603_1608Metric; MPN C85979
C33, C34, C35, C44, C45, C46: 1u; C_0603_1608Metric; MPN C15849
C36, C47, C48, C49: 47u; CP_EIA-3528-15_AVX-H; MPN C22036
C40, C41: 20p; C_0603_1608Metric; MPN C1648
C42, C43: 2.2u; C_1206_3216Metric; MPN C50254
C102: 100n; C_0603_1608Metric; MPN C14663; not fitted
D1: M7; D_SMA; MPN C95872
D2, D8, D10, D101: B5819WS; my_D_SOD-323; MPN C64886
D3: LED_RGB; my_LED_5mm_RGB_mirror
D6, D7: ESDA6V1BC6; my_SOT-23-6_rotate; MPN C2912546
J1: DC-005; my_DC_Jack
J2, J3: PJ-603A; MPN C309273
J4: 1.77" LCD Module; LCD_Display_1.77inch
J5: DEBUG; PinSocket_1x06_P2.54mm_Horizontal
J6: TYPE-C-31-M-12; USB_C_TYPE-C-31-M-12; MPN C165948
J101: PJ-313D; PJ-313D_HOOYA; MPN C668608
J102, J103, J104: PJ-313D; PJ-313D_HOOYA; MPN C668608; not fitted
JP1, JP2: JP; AD_GND_Jumper
L1: 10uH; L_7.3x7.3_H3.5; MPN C2827354
Q1: AO3401A; SOT-23_rotate; MPN C15127
R1, R2: 1M; R_0603_1608Metric; MPN C22935
R3, R4, R15, R16: 1k; R_0603_1608Metric; MPN C21190
R5, R6, R31: 470R; R_0603_1608Metric; MPN C23179
R7, R8, R9, R10, R28, R29, R68, R69: 4.7k; R_0603_1608Metric; MPN C23162
R11, R12, R13, R14: 5.6k; R_0603_1608Metric; MPN C23189
R17, R18: 100k; R_0603_1608Metric; MPN C25803
R19, R20, R21, R22, R23, R33, R34, R35, R36, R37: 22R; R_0603_1608Metric; MPN C23345
R24, R25, R27, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R61, R62, R63, R64, R65, R66: 10k; R_0603_1608Metric; MPN C25804
R26: 5.1R; R_0603_1608Metric; MPN C25197
R30, R32, R67, R101: 220R; R_0603_1608Metric; MPN C22962
R38: 0R; R_1206_3216Metric; MPN C17888
R39, R40: 5.1k; R_0603_1608Metric; MPN C23186
R60: 12k; R_0603_1608Metric; MPN C22790
R70, R71, R72, R73: 2.2k; R_0603_1608Metric; MPN C4190
R102, R103, R104: 100R; R_1206_3216Metric; MPN C17901; not fitted
R105: 10R; R_1206_3216Metric; MPN C17903; not fitted
R106, R107, R108, R109, R110, R111, R112, R113: 10k; R_0603_1608Metric; MPN C25804; not fitted
SW0: SW0; my_SW_PUSH_12mm_narrow
SW1: SW1; my_SW_PUSH_12mm_narrow
SW2: SW2; my_SW_PUSH_12mm_narrow
SW3: SW3; my_SW_PUSH_12mm_narrow
SW4: SW4; spst_momentary_sw_foot
SW5: SW5; spst_momentary_sw_foot
SW6, SW7, SW8, SW9: EC12D1524403
TP1: +8.1V; my_TestPoint_1.2mm
TP2: +3.3V; my_TestPoint_1.2mm
TP3: BOOT0; my_TestPoint_1.2mm
TP4: L_OUT+; my_TestPoint_1.2mm
TP5: L_OUT-; my_TestPoint_1.2mm
TP6: R_OUT+; my_TestPoint_1.2mm
TP7: R_OUT-; my_TestPoint_1.2mm
TP8: L_IN+; my_TestPoint_1.2mm
TP9: R_IN+; my_TestPoint_1.2mm
TP10: VCOM; my_TestPoint_1.2mm
TP11: +5V; my_TestPoint_1.2mm
TP12: VB_L; my_TestPoint_1.2mm
TP13: VB_R; my_TestPoint_1.2mm
TP14: L_IN; my_TestPoint_1.2mm
TP15: R_IN; my_TestPoint_1.2mm
TP16: R_OUT; my_TestPoint_1.2mm
TP17: L_OUT; my_TestPoint_1.2mm
U1: AP63203WU; my_SOT-23-6_rotate; MPN C780769
U2: L78M05ABDT; my_DPAK_TO-252-2; MPN C58069
U3: OPA1679; TSSOP-14_4.4x5mm_P0.65mm_rotate; MPN C2057264
U4: CS4272; TSSOP-28_4.4x9.7mm_P0.65mm_rotate
U5: STM32H723VGT6; LQFP-100_14x14mm_P0.5mm_rotate
U6: HT7533-1; SOT-89-3-rotate; MPN C14289
U7: M24M01; SOIC-8_3.9x4.9mm_P1.27mm_rotate
U101: TLP2361; SO-5_4.4x3.6mm_P1.27mm_rotate; MPN C107626
U102: SN74LVC1G07DBVR; my_SOT-23-5_rotate; MPN C7394020; not fitted
Y1: 8MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm; MPN C115962

Connections:
+3.3V: C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C33.2, C44.2, C52.2, C101.2, C102.2, J4.2, J5.1, L1.2, Q1.2 (S), R24.1, R25.2, R27.1, R28.1, R29.1, R42.1, R43.1, R44.1, R45.1, R46.1, R47.1, R48.1, R49.1, R50.1, R51.1, R52.1, R53.1, R54.1, R55.1, R56.1, R57.1, R58.1, R59.1, R68.1, R69.1, R102.2, R103.2, R104.2, R106.1, R108.1, R110.1, R112.1, TP2.1, U1.1 (FB), U4.10 (VL), U5.6 (VBAT), U5.11 (VDD), U5.20 (VREF+), U5.21 (VDDA), U5.27 (VDD), U5.40 (PE10), U5.50 (VDD), U5.75 (VDD), U5.100 (VDD), U7.8 (VCC), U101.6 (VDD), U102.5 (VCC)
+5V: C16.1, C35.2, D2.2 (A), R26.2, TP11.1, U2.3 (VO), U4.20 (VA)
BOOT0: R63.2, TP3.1, U5.94 (BOOT0)
CODEC_RST: R25.1, U4.14 (~RST), U5.98 (PE1)
EEPROM_SCL: R69.2, U5.46 (PB10), U7.6 (SCL)
EEPROM_SDA: R68.2, U5.47 (PB11), U7.5 (SDA)
EX_PDL: R109.2, U5.28 (PA4)
EX_PDL_SENS: R107.2, U5.30 (PA6)
EX_SW_A: R111.2, U5.34 (PB0)
EX_SW_B: R113.2, U5.35 (PB1)
GNDA: C1.2, C2.2, C4.2, C15.2, C16.2, C21.1, C22.1, C27.1, C28.1, C35.1, C36.2, C37.2, C38.2, C39.2, C47.2, C48.2, C49.2, C50.2, C51.2, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, J2.S, J3.S, JP1.2 (B), JP2.2 (B), R17.1, R18.1, R61.1, SW6.MP, SW7.MP, SW8.MP, SW9.MP, U2.2 (GND), U3.11 (V-), U4.21 (AGND); also elsewhere on the board
GNDD: C3.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C33.1, C34.1, C40.2, C41.2, C42.2, C43.2, C44.1, C45.1, C46.1, C52.1, C101.1, C102.1, D3.2 (K), D6.2 (COM), D6.5 (COM), D7.2 (COM), D7.5 (COM), J1.1, J4.1, J5.3, J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), J6.S1 (SHIELD), J102.S, J103.S, J104.S, JP1.1 (A), JP2.1 (A), R39.1, R40.1, R41.2, R64.2, R65.2, R66.2, SW0.1, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.C, SW6.S2, SW7.C, SW7.S2, SW8.C, SW8.S2, SW9.C, SW9.S2, U1.4 (GND), U4.2 (XTI), U4.8 (DGND), U5.10 (VSS), U5.19 (VSSA), U5.26 (VSS), U5.41 (PE11), U5.42 (PE12), U5.43 (PE13), U5.49 (VSS), U5.74 (VSS), U5.99 (VSS), U6.1 (GND), U7.1 (E0), U7.2 (E1), U7.3 (E2), U7.4 (VSS), U7.7 (~WC), U101.4 (GND), U102.3 (GND)
LCD_BACKLIGHT: R67.2, U5.44 (PE14)
LCD_CS: R37.1, U5.62 (PD15)
LCD_RES: R35.1, U5.61 (PD14)
LCD_RS: R36.1, U5.60 (PD13)
LCD_SCK: R33.1, U5.52 (PB13)
LCD_SDA: R34.1, U5.54 (PB15)
LED_B: D10.1 (K), R32.2, U5.80 (PC12)
LED_G: R31.2, U5.90 (PB4(NJTRST))
LED_R: R30.2, U5.92 (PB6)
LRCK: R20.1, U5.3 (PE4)
L_IN+: C21.2, R5.2, TP8.1, U4.17 (AINA+)
L_OUT+: C24.2, TP4.1, U4.25 (AOUTA+)
L_OUT-: C23.2, TP5.1, U4.24 (AOUTA-)
MCLK: R19.1, U5.1 (PE2)
MIDI_RX: U5.56 (PD9), U101.5 (VO)
MIDI_TX: U5.55 (PD8), U102.2
NRST: D6.4 (TVS3), J5.5, R27.2, U5.14 (NRST)
unnamed: C17.1, R1.2, R3.1
unnamed: C17.2, J2.T, TP14.1
unnamed: C18.1, R2.2, R4.1
unnamed: C18.2, J2.R, TP15.1
unnamed: C19.2, R5.1
unnamed: C20.2, R6.1
unnamed: C23.1, R9.1
unnamed: C24.1, R7.1
unnamed: C25.1, R10.1
unnamed: C26.1, R8.1
unnamed: C27.2, R7.2, R11.2, R72.1
unnamed: C28.2, R8.2, R12.2, R73.1
unnamed: C29.2, C31.1, R13.2, U3.7
unnamed: C30.2, C32.1, R14.2, U3.1
unnamed: C31.2, R15.1
unnamed: C32.2, R16.1
unnamed: C42.1, U5.48 (VCAP)
unnamed: C43.1, U5.73 (VCAP)
unnamed: C53.2, J3.T, R15.2, R17.2, TP17.1
unnamed: C54.2, J3.R, R16.2, R18.2, TP16.1
unnamed: C55.2, R9.2, R13.1, R70.1
unnamed: C56.2, R10.2, R14.1, R71.1
unnamed: D1.2 (A), J1.2
unnamed: D3.4 (BA), R32.1
unnamed: D3.3 (GA), R31.1
unnamed: D3.1 (RA), R30.1
unnamed: C45.2, D7.4 (TVS3), D8.1 (K), J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS), U6.2 (VIN)
unnamed: C46.2, D8.2 (A), D10.2 (A), R41.1, R62.1, R63.1, U6.3 (VOUT)
unnamed: D101.2 (A), J101.T, U101.3 (K)
unnamed: D101.1 (K), R101.1, U101.1 (A)
unnamed: J4.3, R33.2, R64.1
unnamed: J4.4, R34.2, R65.1
unnamed: J4.5, R35.2
unnamed: J4.6, R36.2
unnamed: J4.7, R37.2
unnamed: J4.8, R38.2
unnamed: J6.A5 (CC1), R39.2
unnamed: J6.B5 (CC2), R40.2
unnamed: J101.R, R101.2
unnamed: J102.R, R102.1, R103.1, R104.1
unnamed: J102.T, R105.1
unnamed: J103.R, R106.2, R107.1
unnamed: J103.T, R108.2, R109.1
unnamed: J104.R, R110.2, R111.1
unnamed: J104.T, R112.2, R113.1
unnamed: Q1.3 (D), R38.1
unnamed: Q1.1 (G), R66.1, R67.1
unnamed: R105.2, U102.4
unnamed: C5.2, U1.6 (BST)
unnamed: C5.1, L1.1, U1.5 (SW)
unnamed: C58.2, R73.2, U3.3 (+)
unnamed: C30.1, R71.2, U3.2 (-)
unnamed: C57.2, R72.2, U3.5 (+)
unnamed: C29.1, R70.2, U3.6 (-)
unnamed: R4.2, U3.10 (+)
unnamed: C20.1, U3.8, U3.9 (-)
unnamed: R3.2, U3.12 (+)
unnamed: C19.1, U3.13 (-), U3.14
unnamed: R24.2, U4.13 (AD0/~CS(I2S/~LJ))
unnamed: C51.1, U4.16 (AINA-)
unnamed: C50.1, U4.19 (AINB-)
unnamed: C36.1, C37.1, U4.22 (FILT+)
unnamed: R20.2, U4.4 (LRCK)
unnamed: R19.2, U4.3 (MCLK)
unnamed: R21.2, U4.5 (SCLK)
unnamed: R23.2, U4.7 (SDIN)
unnamed: R22.2, U4.6 (SDOUT(M/~S))
unnamed: C34.2, R26.1, U4.9 (VD)
unnamed: C41.1, U5.12 (PH0), Y1.2
unnamed: C40.1, U5.13 (PH1), Y1.1
RE0A: R48.2, SW6.A, U5.91 (PB5)
RE0B: R49.2, SW6.B, U5.93 (PB7)
RE1A: R52.2, SW7.A, U5.84 (PD3)
RE1B: R51.2, SW7.B, U5.86 (PD5)
RE2A: R55.2, SW8.A, U5.67 (PA8)
RE2B: R54.2, SW8.B, U5.77 (PA15(JTDI))
RE3A: R58.2, SW9.A, U5.66 (PC9)
RE3B: R57.2, SW9.B, U5.64 (PC7)
R_IN+: C22.2, R6.2, TP9.1, U4.18 (AINB+)
R_OUT+: C26.2, TP6.1, U4.26 (AOUTB+)
R_OUT-: C25.2, TP7.1, U4.27 (AOUTB-)
SCLK: R21.1, U5.4 (PE5)
SCL/M0: R28.2, U4.11 (SCL/CCLK(M0)), U5.95 (PB8)
SDA/M1: R29.2, U4.12 (SDA/CDIN(M1)), U5.96 (PB9)
SDIN: R23.1, U5.2 (PE3)
SDOUT: R22.1, U5.5 (PE6)
SW0: R42.2, SW0.2, U5.88 (PD7)
SW1: R43.2, SW1.2, U5.83 (PD2)
SW2: R44.2, SW2.2, U5.81 (PD0)
SW3: R45.2, SW3.2, U5.65 (PC8)
SW4: R46.2, SW4.2, U5.79 (PC11)
SW5: R47.2, SW5.2, U5.78 (PC10)
SW6: R50.2, SW6.S1, U5.87 (PD6)
SW7: R53.2, SW7.S1, U5.85 (PD4)
SW8: R56.2, SW8.S1, U5.82 (PD1)
SW9: R59.2, SW9.S1, U5.63 (PC6)
SWC: D6.1 (TVS1), J5.2, U5.76 (PA14(JTCK)
SWD: D6.6 (TVS4), J5.4, U5.72 (PA13(JTMS)
SWO: D6.3 (TVS2), J5.6, U5.89 (PB3(JTDO)
USB_D+: D7.1 (TVS1), J6.A6 (D+), J6.B6 (D+), U5.71 (PA12)
USB_D-: D7.6 (TVS4), J6.A7 (D-), J6.B7 (D-), U5.70 (PA11)
VB: C47.1, C48.1, C49.1, R1.1, R2.1, R11.1, R12.1, R60.2, R61.2, TP12.1, TP13.1
VBUS_SENS: R62.2, U5.68 (PA9)
VCC: C1.1, C2.1, C3.1, C4.1, C15.1, D1.1 (K), D2.1 (K), R60.1, TP1.1, U1.2 (EN), U1.3 (IN), U2.1 (VI), U3.4 (V+)
VCOM: C38.1, C39.1, TP10.1, U4.15 (VCOM)

Notes on the sheet:
[Power]
I2C
Chlorine
[MIDI In]
MIDI_OUT
SAI(I2S)
出力バッファ ローパスフィルタ
STM32 マイコン
[LCD]
オーディオコーデック
EEPROM
LED
Rev.D Apr. 2025 github.com/kanengomibako
スイッチ ロータリーエンコーダ
ディスプレイ
[Switches and LED]
SPI
USB
[MCU]
MIDI
入力バッファ ローパスフィルタ
[EEPROM]
[Audio In/Out]
[Audio Codec]
[USB]
PE10-PE13: Hardware Version

Board: 4 copper layers, 76.0 x 100.0 mm, 206 parts (12 on the bottom side), 134 nets.

Other parts of the board:
*: m; MountingHole_3.2mm_M3_ISO7380_Pad

Their connections:
GNDA: *.1; also elsewhere on the board

## KiCad design KiCad/enclosure/chlorineBox-sideUL.kicad_pcb

Board: 2 copper layers, 82.0 x 87.0 mm, 3 parts (3 on the bottom side), 3 nets, no tracks yet.

Parts:
J143: SWpin; PinHeader_1x03_P2.54mm_Vertical
SW5, SW6: sw; my_conn

Connections:
GND: J143.2, SW5.2, SW6.2
unnamed: J143.1, SW6.1
unnamed: J143.3, SW5.1

## Commit log

2025-04-07 Update Docs
2025-04-09 Upload Src/example
2025-04-11 Update Schematic
2025-04-26 Update Docs, KiCad
2025-05-17 Move Chlorine Article
2026-04-08 Update Example
